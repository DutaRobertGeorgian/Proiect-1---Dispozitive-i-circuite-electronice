** Profile: "SCHEMATIC1-bias"  [ C:\Users\Robert\Desktop\proiect 1\FINALLLLL\proiect_osc_triunghiular-pspicefiles\schematic1\bias.sim ]

** Creating circuit file "bias.cir"
** WARNING: THIS AUTOMATICALLY GENERATED FILE MAY BE OVERWRITTEN BY SUBSEQUENT SIMULATIONS

*Libraries:
* Profile Libraries :
* Local Libraries :
.LIB "C:/Users/Robert/Desktop/proiect 1/lib_modelepspice_anexa_1/modele_a1_lib/bzx84c2v7.lib"
.LIB "C:/Users/Robert/Desktop/proiect 1/lib_modelepspice_anexa_1/modele_a1_lib/1n4148.lib"
.LIB "C:/Users/Robert/Desktop/proiect 1/lib_modelepspice_anexa_1/modele_a1_lib/bc856b.lib"
.LIB "C:/Users/Robert/Desktop/proiect 1/lib_modelepspice_anexa_1/modele_a1_lib/bc846b.lib"
.LIB "C:/Users/Robert/Desktop/proiect 1/lib_modelepspice_anexa_1/modele_a1_lib/bc817-25.lib"
.LIB "C:/Users/Robert/Desktop/proiect 1/lib_modelepspice_anexa_1/modele_a1_lib/bc807-25.lib"
* From [PSPICE NETLIST] section of C:\Users\Robert\AppData\Roaming\SPB_Data\cdssetup\OrCAD_PSpice\17.4.0\PSpice.ini file:
.lib "C:\Users\Robert\Desktop\proiect 1\Lib_ModelePSpice_Anexa_1\Lib_ModelePSpice_Anexa_1\Modele_A1_lib\MMBFJ309LT1G.lib"
.lib "C:\Users\Robert\Desktop\proiect 1\Lib_ModelePSpice_Anexa_1\Lib_ModelePSpice_Anexa_1\Modele_A1_lib\MMBFJ177LT1G.lib"
.lib "C:\Users\Robert\Desktop\proiect 1\Lib_ModelePSpice_Anexa_1\Lib_ModelePSpice_Anexa_1\Modele_A1_lib\MJD32CG.lib"
.lib "C:\Users\Robert\Desktop\proiect 1\Lib_ModelePSpice_Anexa_1\Lib_ModelePSpice_Anexa_1\Modele_A1_lib\MJD31CG.lib"
.lib "C:\Users\Robert\Desktop\proiect 1\Lib_ModelePSpice_Anexa_1\Lib_ModelePSpice_Anexa_1\Modele_A1_lib\IRFR120NPBF.lib"
.lib "C:\Users\Robert\Desktop\proiect 1\Lib_ModelePSpice_Anexa_1\Lib_ModelePSpice_Anexa_1\Modele_A1_lib\BZX84C10.lib"
.lib "C:\Users\Robert\Desktop\proiect 1\Lib_ModelePSpice_Anexa_1\Lib_ModelePSpice_Anexa_1\Modele_A1_lib\BZX84C8V2.lib"
.lib "C:\Users\Robert\Desktop\proiect 1\Lib_ModelePSpice_Anexa_1\Lib_ModelePSpice_Anexa_1\Modele_A1_lib\BZX84C6V8.lib"
.lib "C:\Users\Robert\Desktop\proiect 1\Lib_ModelePSpice_Anexa_1\Lib_ModelePSpice_Anexa_1\Modele_A1_lib\BZX84C6V2.lib"
.lib "C:\Users\Robert\Desktop\proiect 1\Lib_ModelePSpice_Anexa_1\Lib_ModelePSpice_Anexa_1\Modele_A1_lib\BZX84C5V6.lib"
.lib "C:\Users\Robert\Desktop\proiect 1\Lib_ModelePSpice_Anexa_1\Lib_ModelePSpice_Anexa_1\Modele_A1_lib\BZX84C5V1.lib"
.lib "C:\Users\Robert\Desktop\proiect 1\Lib_ModelePSpice_Anexa_1\Lib_ModelePSpice_Anexa_1\Modele_A1_lib\BZX84C2V7.lib"
.lib "C:\Users\Robert\Desktop\proiect 1\Lib_ModelePSpice_Anexa_1\Lib_ModelePSpice_Anexa_1\Modele_A1_lib\BC856B.lib"
.lib "C:\Users\Robert\Desktop\proiect 1\Lib_ModelePSpice_Anexa_1\Lib_ModelePSpice_Anexa_1\Modele_A1_lib\BC846B.lib"
.lib "C:\Users\Robert\Desktop\proiect 1\Lib_ModelePSpice_Anexa_1\Lib_ModelePSpice_Anexa_1\Modele_A1_lib\BC817-25.lib"
.lib "C:\Users\Robert\Desktop\proiect 1\Lib_ModelePSpice_Anexa_1\Lib_ModelePSpice_Anexa_1\Modele_A1_lib\BC807-25.lib"
.lib "C:\Users\Robert\Desktop\proiect 1\Lib_ModelePSpice_Anexa_1\Lib_ModelePSpice_Anexa_1\Modele_A1_lib\1N4148.lib"
.lib "nom.lib"

*Analysis directives:
.TRAN  0 2m  0 0.01m SKIPBP
.OPTIONS ADVCONV
.PROBE64 V(alias(*)) I(alias(*)) W(alias(*)) D(alias(*)) NOISE(alias(*))
.INC "..\SCHEMATIC1.net"

.END
